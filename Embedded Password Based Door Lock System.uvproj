# Keil uVision project Embedded Password Based Door Lock System.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Embedded Password Based Door Lock System +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: Main.c lcd.c keypad.c EEPROM.c i2c.c delay.c delays.c
